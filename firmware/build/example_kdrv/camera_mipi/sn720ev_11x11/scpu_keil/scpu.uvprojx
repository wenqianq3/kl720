# Keil uVision project scpu.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: fw_scpu
  BeforeMake: pre_build.bat
  AfterMake: fromelf.exe --bin "!L" --output ".\Objects\tmp.bin"
  AfterMake: post_build.bat tmp.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KL720_IPC, KL720_DBG, TARGET_SCPU, KL720_SCPU, LOG_ENABLE DSP_NPU_PERF_PROFILE, MIPI_EXAMPLE
  c misc: --gnu
  c include: ..\..\..\..\..\platform\kl720\common;..\..\..\..\..\platform\kl720\scpu\drv\include\11x11;..\..\..\..\..\platform\kl720\scpu\drv\include;..\..\..\..\..\platform\kl720\common;..\..\..\..\..\platform\kl720\scpu\rtos\rtx\include;..\..\..\..\..\platform\dev\include;..\..\..\..\..\platform\board;..\..\..\..\..\mdw\include;..\..\..\..\..\app\include;..\..\..\..\..\app;..\..\..\..\..\include;..\..\sn720ev_11x11;..\..\main_scpu\include
  asm misc: --cpreproc
  asm include: ..\..\sn720ev_11x11;..\..\..\..\..\platform\kl720\common;..\..\..\..\..\platform\board;..\..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\platform\kl720\scpu\scpu_common.sct
  group application
    ../: project.h
    ../../main_scpu/: system_init.c driver_init.c ex_cam_main.c
  group middleware
    ../../../../../mdw/console/: kmdw_console.c
    ../../../../../mdw/camera/: kmdw_camera.c kmdw_camera_kl720.c kmdw_sensor.c
    ../../../../../mdw/memory/: kmdw_memory.c
    ../../../../../mdw/power/: kmdw_power_manager.c
  group device
    ../../../../../platform/dev/sensor/: kdev_sensor_sc132gs.c kdev_sensor_gc2145.c kdev_sensor.c
  group driver
    ../../../../../platform/kl720/scpu/drv/: kdrv_clock.c kdrv_ddr.c kdrv_dpi2ahb.c kdrv_i2c.c kdrv_mipicsirx.c kdrv_power.c kdrv_system.c kdrv_uart.c kdrv_timer.c kdrv_pinmux.c kdrv_rtc.c
  group startup
    ../../../../../platform/kl720/scpu/startup/: startup_asm.s startup.c
  group rtx
    ../../../../../platform/kl720/scpu/rtos/rtx/: irq_cm4f.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
