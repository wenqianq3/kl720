# Keil uVision project scpu.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: fw_scpu
  BeforeMake: pre_build.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LOG_ENABLE
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\sn72096_9x9;..\..\..\..\..\..\firmware\platform\kl720\scpu\rtos\rtx\include;..\..\..\..\..\..\firmware\platform\kl720\common;..\..\..\..\..\..\firmware\platform\kl720\scpu\drv\include;..\..\main_scpu\include;..\..\..\..\..\..\firmware\platform\kl720\common;..\..\..\..\..\..\firmware\platform\board\board_sn72096_9x9;..\..\..\..\..\..\firmware\platform\dev\include;..\..\..\..\..\..\firmware\mdw\include;..\..\..\..\..\..\firmware\include;..\..\..\..\..\platform\kl720\scpu\rtos\rtx\include;..\..\..\..\..\platform\kl720\scpu\drv\include\9x9
  asm misc: --cpreproc
  asm include: ..\..\sn72096_9x9;..\..\..\..\..\..\firmware\platform\kl720\common;..\..\..\..\..\..\firmware\platform\board\board_sn72096_9x9;..\..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\firmware\platform\kl720\scpu\scpu_common.sct
  group app
    ../: project.h
    ../../main_scpu/: driver_init.c system_init.c ex_i2s_main.c wm8731.c ex_i2s_test.c
  group mdw
    ../../../../../../firmware/mdw/console/: kmdw_console.c
  group drv
    ../../../../../../firmware/platform/kl720/scpu/drv/: kdrv_uart.c kdrv_clock.c kdrv_ddr.c kdrv_power.c kdrv_system.c kdrv_pwm.c kdrv_pinmux.c kdrv_timer.c
    ../../../../../platform/kl720/scpu/drv/: kdrv_i2c.c kdrv_i2s.c kdrv_gdma.c kdrv_usbd3.c
  group startup
    ../../../../../../firmware/platform/kl720/scpu/startup/: startup_asm.s startup.c
  group rtx
    ../../../../../platform/kl720/scpu/rtos/rtx/: irq_cm4f.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
