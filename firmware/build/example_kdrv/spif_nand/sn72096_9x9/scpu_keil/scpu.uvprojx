# Keil uVision project scpu.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: fw_scpu
  BeforeMake: pre_build.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\include;..\..\..\..\..\mdw\include;..\..\..\..\..\app\include;..\..\..\..\..\platform\kl720\scpu\drv\include;..\..\..\..\..\platform\kl720\scpu\drv\include\9x9;..\..\..\..\..\platform\kl720\common;..\..\..\..\..\platform\dev\include;..\..\..\..\..\platform\board;..\..\sn72096_9x9;..\..\..\..\..\platform\kl720\scpu\rtos\rtx\include;..\..\main_scpu\include
  asm misc: --cpreproc
  asm include: ..\..\sn72096_9x9;..\..\..\..\..\platform\kl720\common;..\..\..\..\..\platform\board;..\..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\firmware\platform\kl720\scpu\scpu_common.sct
  group app
    ../../main_scpu/: main.c system_init.c driver_init.c
  group middleware
    ../../../../../mdw/console/: kmdw_console.c
    ../../../../../mdw/memory/: kmdw_memory.c
  group device
    ../../../../../platform/dev/nand/winbond/: kdev_flash_winbond_nand.c
  group driver
    ../../../../../platform/kl720/scpu/drv/: kdrv_clock.c kdrv_pinmux.c kdrv_power.c kdrv_spif_nand.c kdrv_system.c kdrv_uart.c kdrv_ddr.c kdrv_gdma3.c
  group startup
    ../../../../../platform/kl720/scpu/startup/: startup.c startup_asm.s
  group rtx
    ../../../../../platform/kl720/scpu/rtos/rtx/: irq_cm4f.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
