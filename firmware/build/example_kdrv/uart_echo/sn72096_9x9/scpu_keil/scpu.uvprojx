# Keil uVision project scpu.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: fw_scpu
  BeforeMake: pre_build.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KL720
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\main_scpu\include;..\..\..\..\..\..\firmware\mdw\include;..\..\..\..\..\..\firmware\include;..\..\..\..\..\..\firmware\platform\kl720\scpu\drv\include;..\..\..\..\..\platform\kl720\scpu\drv\include\9x9;..\..\..\..\..\..\firmware\platform\board\board_sn72096_9x9;..\..\..\..\..\..\firmware\platform\dev\include;..\..\..\..\..\..\firmware\platform\kl720\common;..\..\sn72096_9x9;..\..\..\..\..\platform\kl720\scpu\rtos\rtx\include
  asm misc: --cpreproc
  asm include: ..\..\sn72096_9x9;..\..\..\..\..\..\firmware\platform\kl720\common;..\..\..\..\..\..\firmware\platform\board\board_sn72096_9x9;..\..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\firmware\platform\kl720\scpu\scpu_common.sct
  group app
    ../../main_scpu/: ex_uart_echo.c
    ../: project.h
  group drv
    ../../../../../../firmware/platform/kl720/scpu/drv/: kdrv_uart.c
    ../../../../../platform/kl720/scpu/drv/: kdrv_system.c kdrv_power.c kdrv_clock.c
  group startup
    ../../../../../../firmware/platform/kl720/scpu/startup/: startup_asm.s startup.c
