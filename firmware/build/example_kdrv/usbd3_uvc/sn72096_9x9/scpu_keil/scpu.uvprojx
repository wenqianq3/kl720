# Keil uVision project scpu.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: fw_scpu
  BeforeMake: pre_build.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\..\..\..\..\include;..\..\..\..\..\mdw\include;..\..\..\..\..\platform\kl720\scpu\drv\include;..\..\..\..\..\platform\kl720\scpu\drv\include\9x9;..\..\..\..\..\platform\kl720\common;..\..\..\..\..\platform\board\board_sn72096_9x9;..\..\sn72096_9x9;..\..\..\..\..\platform\kl720\scpu\rtos\rtx\include;..\..\..\..\..\platform\dev\include
  asm misc: --cpreproc
  asm include: ..\..\sn72096_9x9;..\..\..\..\..\..\firmware\platform\kl720\common;..\..\..\..\..\..\firmware\platform\board\board_sn72096_9x9;..\..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x1ffc2000 size 0x1d000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  scatter file: ..\..\..\..\..\..\firmware\platform\kl720\scpu\scpu_common.sct
  group main
    ../../main_scpu/: ex_usbd3_main.c ex_usbd3_test.c
    ../: project.h
  group driver
    ../../../../../../firmware/platform/kl720/scpu/drv/: kdrv_uart.c kdrv_usbd3.c kdrv_system.c kdrv_clock.c kdrv_rtc.c kdrv_power.c kdrv_ddr.c
    ../../../../../platform/kl720/scpu/drv/: kdrv_gdma.c kdrv_spif_nand.c
  group middleware
    ../../../../../../firmware/mdw/console/: kmdw_console.c
    ../../../../../../firmware/mdw/memory/: kmdw_memory.c
    ../../../../../../firmware/mdw/power/: kmdw_power_manager.c
    ../../../../../mdw/usbd_uvc/: kmdw_usbd_uvc.c
  group startup
    ../../../../../../firmware/platform/kl720/scpu/startup/: startup_asm.s startup.c
  group rtx
    ../../../../../platform/kl720/scpu/rtos/rtx/: irq_cm4f.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group dev
    ../../../../../platform/dev/nand/winbond/: kdev_flash_winbond_nand.c
