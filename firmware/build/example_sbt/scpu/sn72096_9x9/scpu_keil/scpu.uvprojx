# Keil uVision project scpu.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: fw_scpu
  BeforeMake: pre_build.bat
  AfterMake: fromelf.exe --bin "!L" --output ".\Objects\tmp.bin"
  AfterMake: post_build.bat tmp.bin gen_enc
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KL720_IPC
  c misc: --gnu
  c include: ..\..\..\..\..\include;..\..\..\..\..\mdw\include;..\..\..\..\..\app\include;..\..\..\..\..\platform\kl720\scpu\drv\include;..\..\..\..\..\platform\kl720\scpu\drv\include\9x9;..\..\..\..\..\platform\kl720\common;..\..\..\..\..\platform\dev\include;..\..\..\..\..\platform\framework\include;..\..\..\..\..\platform\board;..\..\main_scpu\include;..\;..\..\..\..\..\platform\kl720\scpu\rtos\rtx\include
  asm misc: --cpreproc
  asm include: ..\;..\..\..\..\..\platform\kl720\common;..\..\..\..\..\platform\board;..\..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  scatter file: ..\..\..\..\..\platform\kl720\scpu\scpu_common.sct
  group app
    ../../main_scpu/: main.c driver_init.c system_init.c device_init.c
    ../: project.h
  group mdw
    ../../../../../mdw/console/: kmdw_console.c
    ../../../../../mdw/system/: kmdw_system.c
    ../../../../../mdw/memory/: kmdw_memory.c
    ../../../../../mdw/dfu/: kmdw_dfu.c
    ../../../../../mdw/flash/: kmdw_memxfer.c
    ../../../../../mdw/power/: kmdw_power_manager.c
    ../../../../../mdw/utils/: kmdw_utils_crc.c
  group dev
    ../../../../../platform/dev/nand/winbond/: kdev_flash_winbond_nand.c
  group drv
    ../../../../../platform/kl720/scpu/drv/: kdrv_uart.c kdrv_timer.c kdrv_clock.c kdrv_pinmux.c kdrv_system.c kdrv_power.c kdrv_ddr.c kdrv_spif_nand.c kdrv_ncpu.c kdrv_mpu.c kdrv_rtc.c kdrv_gdma3.c
  group startup
    ../../../../../platform/kl720/scpu/startup/: startup.c startup_asm.s
  group libs
    ../../../../../lib/: system_720.lib
  group rtx
    ../../../../../platform/kl720/scpu/rtos/rtx/: irq_cm4f.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
