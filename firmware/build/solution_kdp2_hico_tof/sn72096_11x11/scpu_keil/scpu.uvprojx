# Keil uVision project scpu.uvprojx, settings and files
target dev (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: comp_ty3
  BeforeMake: pre_build.bat
  AfterMake: fromelf.exe --bin ".\Objects\@L.axf" --output ".\Objects\fw_scpu_tmp.bin"
  AfterMake: post_build.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KL720_IPC, KL720_DBG, TARGET_SCPU, KL720_SCPU, LOG_ENABLE DSP_NPU_PERF_PROFILE, USE_DDR_HEAP_MGR, KDP2_FW, FIFIOQ_LOG_VIA_USB, PDIAGNOSTIC_IGNORE_ASSERT
  c misc: --gnu
  c include: ..\..\..\..\include;..\..\sn72096_11x11;..\..\..\..\platform\kl720\common;..\..\..\..\platform\kl720\common\inc;..\..\..\..\platform\kl720\common\inc\flatcc;..\..\..\..\platform\kl720\common\inc\flatcc\portable\include\std;..\..\..\..\platform\kl720\scpu\drv\include;..\..\..\..\platform\kl720\scpu\drv\include\11x11;..\..\..\..\platform\kl720\scpu\rtos\rtx\include;..\..\..\..\platform\kl720\ncpu\ncpu_main\inc;..\..\main_scpu\include;..\..\..\..\platform\board;..\..\..\..\platform\dev\include;..\..\..\..\platform\framework\include;..\..\..\..\mdw\include;..\..\..\..\mdw\inference;..\..\..\..\app\include;..\..\..\..\app\kcomm;..\..\..\..\app\include;..\..\..\..\app;..\..\..\lib\system\main_scpu\include;..\..\..\..\platform\dev\include
  asm misc: --cpreproc
  asm include: ..\..\sn72096_11x11;..\..\..\..\platform\kl720\common;..\..\..\..\platform\board;..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\platform\kl720\scpu\scpu_common.sct
  link misc: --diag_suppress=L6314
  group main
    ../../main_scpu/: main.c driver_init.c system_init.c device_init.c application_init.c middleware_init.c
    ../: project.h
    ../../main_scpu/include/: task_handler.h
  group inf_app
    ../../../../app/: kdp2_inf_app_tof.c
  group inf_client
    ../../../../mdw/usb_companion/: kdp2_cmd_handler_720.c kdp2_usb_log.c usbd_hal_720.c
    ../../main_scpu/: kdp2_hico_tof.c
  group middleware
    ../../../../mdw/flash/: kmdw_memxfer.c
    ../../../../mdw/console/: kmdw_console.c
    ../../../../mdw/memory/: kmdw_memory.c
    ../../../../mdw/power/: kmdw_power_manager.c
    ../../../../mdw/dfu/: kmdw_dfu.c
    ../../../../mdw/utils/: kmdw_utils_crc.c
    ../../../../mdw/system/: kmdw_system.c
    ../../../../mdw/ipc/: kmdw_ipc.c
    ../../../../mdw/tdc/: kmdw_tdc.c
    ../../../../mdw/errand/: kmdw_errandserv.c
    ../../../../mdw/led/: kmdw_led.c
    ../../../../mdw/model/: kmdw_model.c
    ../../../../mdw/camera/: kmdw_camera.c kmdw_camera_kl720.c kmdw_sensor.c
    ../../../../mdw/inference/: dual_fifo2.c kdp2_inf_generic_raw.c kmdw_inference_720.c kmdw_fifoq_manager.c
    ../../../../mdw/dfs/: kmdw_dfs.c
    ../../../../mdw/tof/: kmdw_tof.c
    ../../../../mdw/jpeg/: kmdw_jpeg.c
  group device
    ../../../../platform/dev/nand/winbond/: kdev_flash_winbond_nand.c
    ../../../../platform/dev/sensor/: kdev_sensor.c kdev_sensor_irs2877c.c
  group driver
    ../../../../platform/kl720/scpu/drv/: kdrv_pinmux.c kdrv_gpio.c kdrv_spif_nand.c kdrv_uart.c kdrv_ipc.c kdrv_ncpu.c kdrv_usbd3.c kdrv_clock.c kdrv_rtc.c kdrv_mpu.c kdrv_ddr.c kdrv_power.c kdrv_system.c kdrv_tdc.c kdrv_wdt.c kdrv_gdma3.c kdrv_mipicsirx.c kdrv_dpi2ahb.c kdrv_i2c.c kdrv_timer.c
  group rtx
    ../../../../platform/kl720/scpu/rtos/rtx/: irq_cm4f.s os_systick.c RTX_Config.c rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c task_handler.c
  group startup
    ../../../../platform/kl720/scpu/startup/: startup.c startup_asm.s
  group libs
    ../../../../lib/: kmdw_dfs_fuzzy_720.lib system_720.lib
